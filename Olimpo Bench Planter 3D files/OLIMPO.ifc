Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:56:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:56:18 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{BE998313-2F6E-41EF-9BA9-B2D55EB47A42}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:56:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:56:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:56:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAPP016 - GRANITO - 598 Lt, Panca OLIMPO:0PAPP016 - GRANITO - 598 Lt:178820
In: 0 - Piano Terra
Type - Material: GRANITO BIANCO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca OLIMPO
Type - Dati identità - BIM Name: OLIMPO - 598 Lt; BIM Object Type: PANCHINE - BENCHES; Code: 0PAPP016; Designer: BELLITALIA DESIGN; Family Name: OLIMPO COLLECTION; Nome del tipo: 0PAPP016 - GRANITO - 598 Lt; URL Eng: https://www.bellitalia.net/prodotti/fioriere/olimpo/; URL Ita: https://www.bellitalia.net/en/products/planters/olimpo/
Type - Dimensioni - Dimensions: H 480 mm X ⌀ 2500 mm X R 1250 mm X r 635 mm
Type - Generale - Accessori: Contenitore interno in acciaio zincato; Accessories: Inner container in galvanized steel; Descrizione Tecnica Famiglia: "Panca mod. “OLIMPO”, costituita da una seduta circolare monolitica dotata di foro passante centrale per la predisposizione non solo di fiori ma anche di piante con fusto."; Descrizione Tecnica per Codice: PANCA OLIMPO IN GRANITO (COLORE A SCELTA) LUCIDO ANTIDECADIMENTO VERNICE; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: Bench model "OLIMPO", consisting of a circular monolithic seat equipped with a central through-hole for the arrangement of not only flowers but also plants with stems.; Technical Description for Article: OLIMPO BENCH IN GRANITO (COLOR TO BE CHOSEN) POLISHED ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE SEDUTA: GRANITO BIANCO; Primary Material: White granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 3383 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAPP016 - GRANITO - 598 Lt
Altro - Famiglia: Panca OLIMPO: 0PAPP016 - GRANITO - 598 Lt; Famiglia e tipo: Panca OLIMPO: 0PAPP016 - GRANITO - 598 Lt; ID tipo: Panca OLIMPO: 0PAPP016 - GRANITO - 598 Lt; Tipo: Panca OLIMPO: 0PAPP016 - GRANITO - 598 Lt
Dimensioni - Area: 5.81206 m2; Volume: 1.40135 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
